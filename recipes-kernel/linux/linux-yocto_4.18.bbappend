include linux-yocto-marvell-37xx.inc
